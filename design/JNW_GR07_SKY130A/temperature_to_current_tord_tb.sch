v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {JNW_GR07_SKY130A/temperature_to_current_tord.sym} 0 -10 0 0 {name=x1}
