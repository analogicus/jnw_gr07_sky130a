v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -100 -180 0 -180 {lab=IBPS_5U}
N -100 180 180 180 {lab=VSS}
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} 420 -90 0 1 {name=xi }
C {devices/ipin.sym} -100 -180 0 0 {name=p1 lab=IBPS_5U}
C {devices/ipin.sym} -100 180 0 0 {name=p2 lab=VSS}
